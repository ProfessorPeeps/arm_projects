# Keil uVision project lab5.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC2146 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: lab5 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x8000
  link misc: --first=mystartup.o(RESET)
  group Source Group 1
    ./: lab5.s
    ../: mystartup.s
